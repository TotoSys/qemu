## hw/ia64/Kconfig
```kconfig
config IA64_MACHINE
    bool
    depends on IA64
    select PCI
    select PIIX
    select MC146818RTC
    select SERIAL_ISA
    select FDC_ISA
    select I8254
```
